# Repository ChethanaRamesh012/Chethana-Ramesh

## KiCad design hardware_challenge.kicad_pcb

Parts:
AE1: ANT-GNSSCP-TH25L1
C1: 1u; C_0402_1005Metric
C2, C3, C4, C5: 100n; C_0402_1005Metric
C6: 1n; C_0402_1005Metric
C7: 10u; C_0402_1005Metric
D1: SMAJ16A; D_SMA
D2: PMEG10020ELR; Nexperia_CFP3_SOD-123W
D3: ASMB-KTF0-0A306; LED_ASMB-KTF0-0A306
J1: 12V INPUT; BarrelJack_CLIFF_FC681465S_SMT_Horizontal
J3: Cable header; PinHeader_2x20_P2.54mm_Horizontal
L1: 12n; L_0402_1005Metric
Q1: SiSS27DN; Vishay_PowerPAK_1212-8_Single
R1: 1k; R_0402_1005Metric
R2, R3: 4k7; R_0402_1005Metric
R4, R5: 10k; R_0402_1005Metric
SW1: TEST BUTTON; SW_SPST_PTS645
U1: L7805; TO-252-2
U2: Teensy4.1; Teensy41
U3: NEO-M8N; ublox_NEO
U4: CY8C9560A-24AXIT; TQFP-100_12x12mm_P0.4mm
U5: MAX2679; WLP-4_0.83x0.83mm_P0.4mm

Connections:
+3.3V: C3.1, C4.1, D3.1 (A), R2.1, R4.1, U2.15 (3V3), U2.46 (3V3), U3.22 (V_BCKP), U3.23 (VCC), U4.32 (Vdd), U4.82 (Vdd), U4.83 (Vdd)
+5V: C2.1, U1.3 (OUT), U2.48 (VIN)
+12V: C1.1, C7.1, D2.1 (K), Q1.1 (S), Q1.2 (S), Q1.3 (S), U1.1 (IN)
BTN_TEST: R4.2, SW1.2, SW1.4, U2.10 (8_TX2_IN1)
CBL_0: J3.1, U4.95 (GPort0_Bit0_PWM7)
CBL_1: J3.2, U4.97 (GPort0_Bit1_PWM5)
CBL_2: J3.3, U4.99 (GPort0_Bit2_PWM3)
CBL_3: J3.4, U4.3 (GPort0_Bit3_PWM1)
CBL_4: J3.5, U4.4 (GPort0_Bit4_PWM7)
CBL_5: J3.6, U4.5 (GPort0_Bit5_PWM5)
CBL_6: J3.7, U4.6 (GPort0_Bit6_PWM3)
CBL_7: J3.8, U4.7 (GPort0_Bit7_PWM1)
CBL_8: J3.9, U4.81 (GPort1_Bit0_PWM6)
CBL_9: J3.10, U4.79 (GPort1_Bit1_PWM4)
CBL_10: J3.11, U4.77 (GPort1_Bit2_PWM2)
CBL_11: J3.12, U4.74 (GPort1_Bit3_PWM0)
CBL_12: J3.13, U4.72 (GPort1_Bit4_PWM6)
CBL_13: J3.14, U4.70 (GPort1_Bit5_PWM4/A6)
CBL_14: J3.15, U4.69 (GPort1_Bit6_PWM2/A5)
CBL_15: J3.16, U4.68 (GPort1_Bit7_PWM0/A4)
CBL_16: J3.17, U4.47 (GPort2_Bit0_PWM14/A3)
CBL_17: J3.18, U4.46 (GPort2_Bit1_PWM12/A2)
CBL_18: J3.19, U4.44 (GPort2_Bit2_PWM8/WD)
CBL_19: J3.20, U4.29 (GPort2_Bit3_PWM11/A1)
CBL_20: J3.21, U4.8 (GPort3_Bit0_PWM7)
CBL_21: J3.22, U4.9 (GPort3_Bit1_PWM5)
CBL_22: J3.23, U4.10 (GPort3_Bit2_PWM3)
CBL_23: J3.24, U4.11 (GPort3_Bit3_PWM1)
CBL_24: J3.25, U4.16 (GPort3_Bit4_PWM15)
CBL_25: J3.26, U4.17 (GPort3_Bit5_PWM13)
CBL_26: J3.27, U4.18 (GPort3_Bit6_PWM11)
CBL_27: J3.28, U4.19 (GPort3_Bit7_PWM9)
CBL_28: J3.29, U4.67 (GPort4_Bit0_PWM6)
CBL_29: J3.30, U4.66 (GPort4_Bit1_PWM4)
CBL_30: J3.31, U4.64 (GPort4_Bit2_PWM2)
CBL_31: J3.32, U4.63 (GPort4_Bit3_PWM0)
CBL_32: J3.33, U4.59 (GPort4_Bit4_PWM14)
CBL_33: J3.34, U4.58 (GPort4_Bit5_PWM12)
CBL_34: J3.35, U4.57 (GPort4_Bit6_PWM10)
CBL_35: J3.36, U4.56 (GPort4_Bit7_PWM8)
CBL_36: J3.37, U4.53 (GPort5_Bit0_PWM10)
CBL_37: J3.38, U4.52 (GPort5_Bit1_PWM8)
CBL_38: J3.39, U4.22 (GPort5_Bit2_PWM11)
CBL_39: J3.40, U4.23 (GPort5_Bit3_PWM9)
CY_INT: U2.45 (23_A9_CRX1_MCLK1), U4.45 (INT)
CY_RST_N: U2.44 (22_A8_CTX1), U4.62 (RESET_N)
CY_SCL: R2.2, U2.16 (24_A10_TX6_SCL2), U4.24 (SCL)
CY_SDA: R3.2, U2.17 (25_A11_RX6_SDA2), U4.28 (SDA)
GND: C1.2, C2.2, C3.2, C4.2, C6.2, C7.2, D1.2 (A2), J1.2, J1.3, R1.2, R3.1, SW1.1, SW1.3, U1.2 (GND), U2.1 (GND), U2.34 (GND), U2.47 (GND), U3.7 (VDD_USB), U3.10 (GND), U3.12 (GND), U3.13 (GND), U3.24 (GND), U4.15 (Vss), U4.30 (A0), U4.34 (Vss), U4.65 (Vss), U4.84 (Vss), U4.85 (Vss), U5.B2 (G)
LED_B: D3.2 (BK), U2.9 (7_RX2_OUT1A)
LED_G: D3.3 (GK), U2.8 (6_OUT1D)
LED_R: D3.4 (RK), U2.7 (5_IN2)
unnamed: AE1.1 (A), R5.1, R5.2, U5.B1
unnamed: C5.2, L1.1
unnamed: D1.1 (A1), J1.1, Q1.5 (D)
unnamed: D2.2 (A), Q1.4 (G), R1.1
unnamed: L1.2, U5.A2
unnamed: C5.1, U3.11 (RF_IN)
unnamed: C6.1, U3.9 (VCC_RF), U5.A1 (Vcc)
UBX-RST_N: U2.6 (4_BCLK2), U3.8 (~RESET)
UBX-RXD: U2.2 (0_RX1_CRX2_CS1), U3.21 (RXD/SPI_MOSI)
UBX-SAFEBOOT: U2.5 (3_LRCLK2), U3.1 (~SAFEBOOT)
UBX-TIMEPULSE: U2.4 (2_OUT2), U3.3 (TIMEPULSE)
UBX-TXD: U2.3 (1_TX1_CTX2_MISO1), U3.20 (TXD/SPI_MISO)

Board: 4 copper layers, 62.1 x 71.7 mm, 25 parts (0 on the bottom side), 64 nets.
